# Keil uVision project MS51FB9AE_t.uvproj, settings and files
target MS51FB9AE_t (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: MS51FB9AE_t +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Library\Device\Include;..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../User/: main.c isp_uart1.c
    ../Library/StdDriver/src/: sys.c uart.c
  group Library
    ../Library/StdDriver/src/: delay.c
  group Startup
    ./: STARTUP.A51
